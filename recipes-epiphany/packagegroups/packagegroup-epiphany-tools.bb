
SUMMARY = "Epiphany tools"
LICENSE = "MIT"

inherit packagegroup

RDEPENDS:packagegroup-epiphany-tools = " \
		epiphany-tools \
		bash \
		"

