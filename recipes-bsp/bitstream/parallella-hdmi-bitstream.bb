include parallella-bitstream.inc
SUMMARY = "Parallella HDMI Bitstreams"
COMPATIBLE_MACHINE = "parallella-hdmi"
