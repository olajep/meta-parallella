include parallella-bitstream.inc
SUMMARY = "Parallella Headless Bitstreams"
COMPATIBLE_MACHINE = "parallella"
